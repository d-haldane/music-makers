# Repository d-haldane/music-makers

## KiCad design hardware/trs-speaker/kicad/trs-speaker.kicad_pcb

Board: 2 copper layers, 40.0 x 40.0 mm, 33 parts (0 on the bottom side), 26 nets, no tracks yet.

Parts:
C1, C2: C433208
C3, C4: ipc_two_pin_landpattern_2
C5, C7, C8, C10, C11, C12, C13, C14: ipc_two_pin_landpattern_5
C6, C9: ipc_two_pin_landpattern
J1: C709355_13
J2, J3, J4: C145801_12
R1, R2: ipc_two_pin_landpattern_3
R3, R4: ipc_two_pin_landpattern_4
R5, R6: ipc_two_pin_landpattern_1
U1, U2: C340238_13
U3: tpa2012
U4, U5, U6, U7: C85831_13
U8, U9: C54949_17

Connections:
G0: R5.1, U3.15, U8.1
G1: R6.1, U3.1, U8.2
GND: C1.2, C2.2, C3.1, C4.1, C6.2, C7.1, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, J1.A12, J1.B12, J2.1, R1.2, R2.2, U3.4, U3.12, U3.18, U3.21, U8.3, U8.4
INL+: C10.2, U3.20
INL-: C8.2, U3.19
INR+: C7.2, U3.16
INR-: C5.2, U3.17
OUTL+: U3.2, U6.1
OUTL-: U3.5, U7.1
OUTR+: U3.14, U4.1
OUTR-: U3.11, U5.1
SDL: U3.7, U9.2
SDR: U3.8, U9.1
VBUS: J1.A9, J1.B9, U1.1
VIN: C2.1, C3.2, C4.2, R5.2, R6.2, U2.2, U3.3, U3.9, U3.13, U9.3, U9.4
amp_fb0_p2: C11.1, J3.2, J3.5, U4.2
amp_fb1_p2: C12.1, J3.1, U5.2
amp_fb2_p2: C13.1, J4.2, J4.5, U6.2
amp_fb3_p2: C14.1, J4.1, U7.2
amp_r0_p1: J2.3, R3.1
amp_r0_p2: C5.1, C6.1, R3.2
amp_r1_p1: J2.2, J2.5, R4.1
amp_r1_p2: C8.1, C9.1, R4.2
filter_c0_p1: C1.1, U1.2, U2.1
rid_p1: J1.A5, R1.1
rid_rid_p1: J1.B5, R2.1

## KiCad design sources/adafruit-music-maker/kicad/Adafruit-Music-Maker-MP3-Shield.kicad_pcb

Parts:
C1, C2: 220uF; PANASONIC_C
C3, C6, C7, C16, C20: 10µF; 0805-NO
C4, C5: 15pF; 0805-NO
C8, C26: 0.1µF; _0805MP
C9, C10, C11: 0.1µF; 0805-NO
C12, C13, C14, C15, C17: 1µF; 0805-NO
C18: 0.047uF; 0805-NO
C19: 10µF; _0805MP
C21, C27, C28: 0.01uF; 0805-NO
C22: 0.01uF; _0805MP
C23, C25: 0.1uF; 0805-NO
C24: 0.1uF; 0805_10MGAP
CN1: 2908-05WB-M6; MICROSD
D1, D2: 1N4148; SOD-323
FB1, FB2: FERITTE; _0805MP
FB3, FB4: ferrite; _0805MP
FID1, FID2, FID3: FIDUCIAL\"\"; FIDUCIAL_1MM
JP1, JP4: PINHD-1X8CLEANBIG; 1X08-CLEANBIG
JP2: PINHD-1X3CB; 1X03-CLEANBIG
JP3: HEADER-1X2ROUND; 1X02_ROUND
JP6: HEADER-1X1070MIL; 1X10_ROUND70
JP7: HEADER-1X770MIL; 1X07_ROUND_70
JP8: PINHD-1X6CB; 1X06-CLEANBIG
LEFTSPK1: 3.5mm Term; TERMBLOCK_1X2-3.5MM
MP3GPIO1: HEADER-2X7_ROUND_70MIL; 2X07_ROUND_70MIL
R1: 1M; 0805-NO
R2, R8, R13, R14, R15, R16, R17, R18: 100K; 0805-NO
R3: 22; 0805-NO
R4: 22; _0805MP
R5: 10; 0805-NO
R6: 100; _0805MP
R7: 100; 0805-NO
R9, R10: 10K; _0805MP
R12: 100K; _0805MP
R19, R20, R21: 10K; 0805-NO
RIGHTSPK1: 3.5mm Term; TERMBLOCK_1X2-3.5MM
SJ1: +6dB; SOLDERJUMPER_ARROW_NOPASTE
SJ2: ICSP_MISO; SOLDERJUMPER_REFLOW_NOPASTE
SJ3: ISCP_SCLK; SOLDERJUMPER_REFLOW_NOPASTE
SJ4: ICSP_MOSI; SOLDERJUMPER_REFLOW_NOPASTE
SJ5: D12_MISO; SOLDERJUMPER_CLOSEDWIRE
SJ6: D13_SCLK; SOLDERJUMPER_CLOSEDWIRE
SJ7: D11_MOSI; SOLDERJUMPER_CLOSEDWIRE
SJ8, SJ9, SJ10, SJ11: SOLDERJUMPERCLOSED; SOLDERJUMPER_CLOSEDWIRE
SJ12: +12dB; SOLDERJUMPER_ARROW_NOPASTE
SW2: SPST_TACT-EVQQ2; EVQ-Q2
U1: VS1053B; LQFP48
U2: AP7312-1833W6-7; SOT23-6
U4: TS2012; WQFN20
U5: 74HC4050D; SOIC16
X1: 19621; 4UCONN_19269
Y1: ABM8G-12.288MHZ-4Y-T3; CRYSTAL_3.2X2.5

Connections:
1.8V: C6.1, U1.5 (CVDD@0), U1.7 (CVDD@1), U1.24 (CVDD@2), U1.31 (CVDD@3), U2.6 (VOUT1)
3.3V: C7.1, C19.1, CN1.4 (SD_VDD), FB1.1, MP3GPIO1.1, MP3GPIO1.3, MP3GPIO1.5, MP3GPIO1.7, MP3GPIO1.9, MP3GPIO1.11, MP3GPIO1.13, R9.2, R10.2, R19.1, R20.1, R21.2, U1.6 (IOVDD@0), U1.14 (IOVDD@1), U1.19 (IOVDD@2), U1.32 (XTEST), U2.1 (VOUT2), U5.1 (VCC)
+5V: C3.1, C11.1, C16.1, C20.1, FB3.1, JP4.4, R12.2, SJ1.2, SJ12.2, U2.3 (EN2), U2.4 (EN1), U2.5 (VIN), U4.3 (PVDD@1), U4.13 (PVDD@2); also elsewhere on the board
/CLKOUT: U1.15 (VCO)
/CS_3V: U1.23 (XCS), U5.4 (2Y)
/CS_5V: JP7.6, R21.1, SJ8.2, U5.5 (2A)
/D8: JP6.10; also elsewhere on the board
/D9: JP6.9; also elsewhere on the board
/D10: JP6.8; also elsewhere on the board
/D11: JP6.7, SJ7.1; also elsewhere on the board
/D12: JP6.6, SJ5.1; also elsewhere on the board
/D13: JP6.5, SJ6.1; also elsewhere on the board
/DREQ: JP3.2, SJ11.2, U1.8 (DREQ)
/GAIN0: SJ1.1, U4.15 (G0)
/GBUF: R5.1, U1.42 (GBUF)
/GPIO0: R2.1, U1.33 (GPIO0)
/GPIO1: MP3GPIO1.2, R8.1, U1.34 (GPIO1)
/GPIO2: MP3GPIO1.4, R13.1, U1.9 (GPIO2/DCLK)
/GPIO3: MP3GPIO1.6, R14.1, U1.10 (GPIO3/SDATA)
/GPIO4: MP3GPIO1.8, R15.1, U1.36 (GPIO4/I2S_LROUT)
/GPIO5: MP3GPIO1.10, R16.1, U1.25 (GPIO5/I2S_MCLK)
/GPIO6: MP3GPIO1.12, R17.1, U1.11 (GPIO6/I2S_SCLK)
/GPIO7: MP3GPIO1.14, R18.1, U1.12 (GPIO7/I2S_SDATA)
/LEFT: C13.1, R3.1, R7.2, U1.46 (LEFT)
/LINE2: C25.1, JP2.3, U1.48 (LINE2)
/L_LINEOUT: C2.-, X1.2, X1.4
/MICN: C23.1, JP2.1, U1.2 (MIC_N)
/MICP: C24.1, JP2.2, U1.1 (MIC_P/LINEIN)
/MISO: CN1.7 (DATA_OUT), SJ2.2, SJ5.2, U1.30 (SO)
/MOSI_3V: CN1.3 (DATA_IN), U1.29 (SI), U5.12 (5Y)
/MOSI_5V: SJ4.2, SJ7.2, U5.11 (5A)
/OUT-L-N: LEFTSPK1.1, U4.5 (OUTL-)
/OUT-L-P: LEFTSPK1.2, U4.2 (OUTL+)
/OUT-R-N: RIGHTSPK1.2, U4.11 (OUTR-)
/OUT-R-P: RIGHTSPK1.1, U4.14 (OUTR+)
/RIGHT: C14.1, R4.1, R6.2, U1.39 (RIGHT)
/RST_3V: U1.3 (XRESET), U5.2 (1Y)
/RST_5V: C26.1, D2.A, JP7.1, R9.1, U5.3 (1A)
/RX: D1.A, R10.1, U1.26 (RX)
/RX_5V: D1.C, JP7.4
/R_LINEOUT: C1.-, X1.3, X1.5
/SCLK_3V: CN1.5 (SCLK), U1.28 (SCLK), U5.10 (4Y)
/SCLK_5V: SJ3.2, SJ6.2, U5.9 (4A)
/SDCS_3V: CN1.2 (CS), U5.15 (6Y)
/SDCS_5V: JP3.1, R20.2, SJ10.2, U5.14 (6A)
/SD_DETECT: CN1.CD1 (CARD_DETECT), JP7.5
/SHUTDOWN: JP7.2, R12.1, U4.7 (SHUTDOWN_L), U4.8 (SHUTDOWN_R)
/TX: JP7.3, U1.27 (TX)
/XDCS_3V: U1.13 (XDCS/BSYNC), U5.6 (3Y)
/XDCS_5V: JP7.7, R19.2, SJ9.2, U5.7 (3A)
/~RESET: D2.C, JP4.6, SW2.A, SW2.A' (P1); also elsewhere on the board
AGND: C8.2, C12.1, C15.1, C17.2, C18.2, C21.2, C22.2, C23.2, C24.2, C25.2, C27.2, C28.2, FB2.2, U1.37 (AGND@0), U1.40 (AGND@1), U1.41 (AGND@2), U1.47 (AGND@3), X1.1
AVDD: C8.1, FB1.2, U1.38 (AVDD@0), U1.43 (AVDD@1), U1.45 (AVDD@2)
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C10.1, C11.2, C16.2, C19.2, C20.2, C26.2, CN1.6 (GND@3), CN1.MT1 (GND@2), CN1.MT2 (GND@1), FB2.1, FB4.1, JP4.2, JP4.3, JP6.4, R2.2, R8.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, SW2.B (S), SW2.B' (S1), U1.4 (DGND@0), U1.16 (DGND@1), U1.20 (DGND@2), U1.21 (DGND@3), U1.22 (DGND@4), U1.35 (GND), U2.2 (GND), U4.4 (PGND@1), U4.12 (PGND@2), U4.21 (THERMAL), U5.8 (GND); also elsewhere on the board
unnamed: C1.+, C28.1, R6.1
unnamed: C2.+, C27.1, R7.1
unnamed: C4.1, R1.2, U1.18 (XTALIN), Y1.2
unnamed: C5.1, R1.1, U1.17 (XTALOUT), Y1.1
unnamed: C9.1, FB3.2, U4.9 (AVDD)
unnamed: C9.2, C10.2, FB4.2, U4.18 (AGND)
unnamed: C12.2, U4.19 (INL-)
unnamed: C13.2, U4.20 (INL+)
unnamed: C14.2, U4.16 (INR+)
unnamed: C15.2, U4.17 (INR-)
unnamed: C17.1, U1.44 (RCAP)
unnamed: C18.1, R5.2
unnamed: C21.1, R3.2
unnamed: C22.1, R4.2
unnamed 71: JP1.1, SJ8.1; also elsewhere on the board
unnamed 72: JP1.2, SJ9.1; also elsewhere on the board
unnamed 73: JP1.3; also elsewhere on the board
unnamed 74: JP1.4, SJ10.1; also elsewhere on the board
unnamed 75: JP1.5, SJ11.1; also elsewhere on the board
unnamed 76: JP1.6; also elsewhere on the board
unnamed 77: JP1.7; also elsewhere on the board
unnamed 78: JP1.8; also elsewhere on the board
unnamed 79: JP4.1; also elsewhere on the board
unnamed 80: JP4.5; also elsewhere on the board
unnamed 81: JP4.7; also elsewhere on the board
unnamed 82: JP4.8; also elsewhere on the board
unnamed 83: JP6.1; also elsewhere on the board
unnamed 84: JP6.2; also elsewhere on the board
unnamed 85: JP6.3; also elsewhere on the board
unnamed 86: JP8.1; also elsewhere on the board
unnamed 87: JP8.2; also elsewhere on the board
unnamed 88: JP8.3; also elsewhere on the board
unnamed 89: JP8.4; also elsewhere on the board
unnamed 90: JP8.5; also elsewhere on the board
unnamed 91: JP8.6; also elsewhere on the board
unnamed 92: SJ2.1; also elsewhere on the board
unnamed 93: SJ3.1; also elsewhere on the board
unnamed 94: SJ4.1; also elsewhere on the board
unnamed: SJ12.1, U4.1 (G1)

Notes on the sheet:
Analog Supply Filtering
C4,C5 = 2*CL - 2*Cstray
C4,C5 = 2*10pF - 2*5pF
C4,C5 = 10pF
VS1053 oscillator requires
1M resistor for DC bias
Set RX to IOVDD if not used
DREQ high = at least 32 bytes
Power Supply/Decoupling
transients during power up which can
damage the earphones and causes
'clicks' ... this setup should minimize
that. See section 8 of
http://www.vlsi.fi/uploads/media/vs10XXan.pdf
Enabling the IC too soon can cause
free in FIFO
Disable SPI boot with GPIO0 low
1 / (2*π*f*Xc)
16 ohm load at 20Hz cuttoff
1 / (6.2832*20hz*16)
C1, C2 =
= 497µF
32 ohm load at 20Hz cuttoff
1 / (6.2832*20hz*32)
= 249µF
Caps: UKA0J471MPD1TD
GAIN1 and GAIN0 have built-in pull down resistors. VS1053 out is 2Vpp so 2V/V gain keeps it under 4.5V for low distortion.
Place C1 as close as possible to PVDD.
Any resistance or inductance in the trace
between the device and the capacitor can
cause a loss in efficiency
Using speakers more resistive than 4-Ω
dramatically increases the thermal performance
by reducing the output current and increasing
the efficiency of the amplifier.
Note on speaker choice (4/8/16/32 ohm, etc.):
The audio input pins (INR+/-
and INL+/-) must run
side-by-side to maximize
common-mode noise cancellation.

Board: 2 copper layers, 68.6 x 53.3 mm, 92 parts (0 on the bottom side), 92 nets.

Other parts of the board:
@HOLE0, @HOLE1, @HOLE2: (no value)
U$41: ARDUINO_R3_ICSP; ARDUINOR3_ICSP
U$50: ADAFRUIT_9MM

Their connections:
+5V: U$41.5V; also elsewhere on the board
/D8: U$41.D8; also elsewhere on the board
/D9: U$41.D9; also elsewhere on the board
/D10: U$41.D10; also elsewhere on the board
/D11: U$41.D11; also elsewhere on the board
/D12: U$41.D12; also elsewhere on the board
/D13: U$41.D13; also elsewhere on the board
/~RESET: U$41.RESET; also elsewhere on the board
GND: U$41.GND, U$41.GND@1, U$41.GND@2, U$41.GND@3; also elsewhere on the board
unnamed 71: U$41.D7; also elsewhere on the board
unnamed 72: U$41.D6; also elsewhere on the board
unnamed 73: U$41.D5; also elsewhere on the board
unnamed 74: U$41.D4; also elsewhere on the board
unnamed 75: U$41.D3; also elsewhere on the board
unnamed 76: U$41.D2; also elsewhere on the board
unnamed 77: U$41.D1; also elsewhere on the board
unnamed 78: U$41.D0; also elsewhere on the board
unnamed 79: U$41.VIN; also elsewhere on the board
unnamed 80: U$41.3V; also elsewhere on the board
unnamed 81: U$41.IOREF; also elsewhere on the board
unnamed 82: U$41.RESERVED; also elsewhere on the board
unnamed 83: U$41.SCL; also elsewhere on the board
unnamed 84: U$41.SDA; also elsewhere on the board
unnamed 85: U$41.AREF; also elsewhere on the board
unnamed 86: U$41.A5; also elsewhere on the board
unnamed 87: U$41.A4; also elsewhere on the board
unnamed 88: U$41.A3; also elsewhere on the board
unnamed 89: U$41.A2; also elsewhere on the board
unnamed 90: U$41.A1; also elsewhere on the board
unnamed 91: U$41.A0; also elsewhere on the board
unnamed 92: U$41.MISO; also elsewhere on the board
unnamed 93: U$41.SCK; also elsewhere on the board
unnamed 94: U$41.MOSI; also elsewhere on the board

## Commit log

2021-10-09 Added the Adafruit Eagle design for their music maker
2021-10-09 added converted KiCAD files
2021-10-09 Kicad import failing
2021-10-09 New error - No match while parsing text drawing
2021-10-09 done for the day - bugs still to be resolved
2021-10-09 Add initial version of imported design
2021-10-09 Got stuck in KiCAD importer - not linking to symbols
2022-05-02 Add components. Getting a schematic error on Windows
2022-05-02 Another schematic crash
2022-06-06 Add a messy pile of CAD and imports
